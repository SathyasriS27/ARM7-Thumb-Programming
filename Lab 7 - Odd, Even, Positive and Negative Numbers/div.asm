	AREA SBCS, CODE, READONLY
	ENTRY
	LDR R0, =0x40000000;
	LDR R1, [R0], #04
	LDR R2, [R0], #04
	LDR R4, =0x40000050
	MOV R3, #00

	CMP R2, R1 
	BLE ELIF1
	CMP R1, #00
	BNE LO1
	MOV R2, #0xFFFFFFFF
	MOV R3, #0xFFFFFFFF

	STR R3, [R4], #04
	STR R3, [R4], #04
	B ENDIF

LO1	SUBS R2, R2, R1
	ADDCS R3, R3, #1
	BCS LO1
	ADD R2, R2, R1
	STR R2, [R4], #04
	STR R3, [R4], #04
	B ENDIF

ELIF1
	BGE ELIF2
	STR R2, [R4], #04
	STR R3, [R4], #04
	B ENDIF

ELIF2 
	MOV R3, #01
	MOV R2, #00
	STR R2, [R4], #04
	STR R3, [R4], #04
	B ENDIF
ENDIF